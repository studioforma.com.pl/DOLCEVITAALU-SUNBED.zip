Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [TrimBim], ExchangeRequirement [Any]
File name: Dolcevita - Sunbed - ver4.ifc
Time: 2024-01-11T16:56:23
Author: Utente
Organization: Trimble
Written by: Trimble SketchUp
Made in: Trimble SketchUp
Authorization: IFC4 model

# IfcBuildingElementProxy (33)
Name
 | Dolcevita - Sunbed model_0 - ObjectType: SketchupGroup
 | Dolcevita - Sunbed model_1 - ObjectType: SketchupGroup
 | Dolcevita - Sunbed model_2 - ObjectType: SketchupGroup
 | Dolcevita - Sunbed model_3 - ObjectType: SketchupGroup
 | Dolcevita - Sunbed model_4 - ObjectType: SketchupGroup
 | Dolcevita - Sunbed model_5 - ObjectType: SketchupGroup
 | Dolcevita - Sunbed model_6 - ObjectType: SketchupGroup
 | Dolcevita - Sunbed model_7 - ObjectType: SketchupGroup
 | Dolcevita - Sunbed model_8 - ObjectType: SketchupGroup
 | Dolcevita - Sunbed model_9 - ObjectType: SketchupGroup
 | Dolcevita - Sunbed model_10 - ObjectType: SketchupGroup
 | Dolcevita - Sunbed model_11 - ObjectType: SketchupGroup
 | Dolcevita - Sunbed model_12 - ObjectType: SketchupGroup
 | Dolcevita - Sunbed model_13 - ObjectType: SketchupGroup
 | Dolcevita - Sunbed model_14 - ObjectType: SketchupGroup
 | Dolcevita - Sunbed model_15 - ObjectType: SketchupGroup
 | Dolcevita - Sunbed model_16 - ObjectType: SketchupGroup
 | Dolcevita - Sunbed model_17 - ObjectType: SketchupGroup
 | Dolcevita - Sunbed model_18 - ObjectType: SketchupGroup
 | Dolcevita - Sunbed model_19 - ObjectType: SketchupGroup
 | Dolcevita - Sunbed model_20 - ObjectType: SketchupGroup
 | Dolcevita - Sunbed model_21 - ObjectType: SketchupGroup
 | Dolcevita - Sunbed model_22 - ObjectType: SketchupGroup
 | Dolcevita - Sunbed model_23 - ObjectType: SketchupGroup
 | Dolcevita - Sunbed model_24 - ObjectType: SketchupGroup
 | Dolcevita - Sunbed model_25 - ObjectType: SketchupGroup
 | Dolcevita - Sunbed model_26 - ObjectType: SketchupGroup
 | Dolcevita - Sunbed model_27 - ObjectType: SketchupGroup
 | Dolcevita - Sunbed model_28 - ObjectType: SketchupGroup
 | Dolcevita - Sunbed model_29 - ObjectType: SketchupGroup
 | Dolcevita - Sunbed model_30 - ObjectType: SketchupGroup
 | Dolcevita - Sunbed model_31 - ObjectType: SketchupGroup
 | Dolcevita - Sunbed model_32 - ObjectType: SketchupGroup
